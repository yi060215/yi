# Keil uVision project adxl345.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: adxl345
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\applications;.\devices;.\devices\MAX30102;.\devices\MQ136;.\devices\SHT40;.\drivers;.\include;.\libs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group Devices/Modules
    ./devices/MAX30102/: dev_max30102.c alg_max30102.c
    ./devices/SHT40/: dev_sht40.c
    ./devices/MQ136/: dev_MQ136.c
  group Devices
    ./devices/: dev_spi.c dev_uart.c dev_gpio.c dev_timer.c dev_i2c.c dev_adc.c
  group Drivers
    ./drivers/: drv_spi.c drv_uart.c drv_gpio.c drv_systick.c drv_i2c.c drv_i2c_sw.c drv_adc.c
  group Libs
    ./libs/delay/: delay.c
    ./libs/printf/: printf.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c app.c app.h
software components: Flex Software:RA Configuration 1.0.0
