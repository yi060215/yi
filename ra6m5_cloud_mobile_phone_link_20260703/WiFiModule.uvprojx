# Keil uVision project WiFiModule.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: WiFiModule
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\include;.\drivers;.\libs;.\ra\fsp\inc;.\ra\fsp\inc\api;.\ra\fsp\inc\instances;.\ra\fsp\src\bsp\cmsis\Device\RENESAS\Include;.\ra\fsp\src\bsp\mcu\all;.\ra\fsp\src\bsp\mcu\ra6m5;.\ra\fsp\src\r_ioport;.\ra\fsp\src\r_sci_uart;.\ra_gen;.\ra_cfg\fsp_cfg\bsp;.\ra_cfg\fsp_cfg;.\ra\arm\CMSIS_5\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group Drivers
    ./drivers/: drv_esp32.c drv_wifi.c
  group Libs
    ./libs/: libs.c
    ./libs/delay/: delay.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
